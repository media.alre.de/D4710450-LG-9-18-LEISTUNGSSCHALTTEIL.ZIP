Properties of the parts of a building model (IFC4)

# File
Description: Leistungsschaltgerät 9 kW für Saunasteuerungen Saunatherm VU / Hygrotherm VU, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: D4710450, Leistungsschaltgerät 9 kW für Saunasteuerungen Saunatherm VU / Hygrotherm VU
In: Raum
Description: Leistungsschaltteil 9 kW (max. 3 kW pro Phase). Hiermit können alle Steuergeräte von 9 kW auf 18 kW Schaltleistung erweitert werden (9 kW über Steuergerät + 9 kW über Lastschaltteil =18 kW Gesamtleistung).; Classification: EC001885 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: D4710450; ModelLabel: LG 9/18; GlobalTradeItemNumber: 4050528023216; ProductURL: https://alre.de/produkt_D4710450
Pset_Specification - NominalLength: 0.237 m; NominalWidth: 0.212 m; NominalDepth: 0.07 m; NetWeight: 1.329
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Zubehör: yes; ETIM-Klasse: EC001885; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-D4710450.pdf
